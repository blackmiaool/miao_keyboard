# Keil uVision project STM32F4-Discovery_Demo.uvprojx, settings and files
target miao_keyboard (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX MANGUSTA_DISCOVERY USE_USB_OTG_FS HSE_VALUE=8000000,USE_STDPERIPH_DRIVER
  c include: .\usb_hid_device;.\;.\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr
    ./: main.c
    ./lib/: startup_stm32f4xx.s
  group usb
    ./usb_hid_device/: tm_stm32f4_delay.c tm_stm32f4_disco.c tm_stm32f4_gpio.c tm_stm32f4_usb_hid_device.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_hid_core.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group lib
    ./lib/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c system_stm32f4xx.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
software components: CMSIS:CORE 4.1.0

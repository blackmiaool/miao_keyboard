# Keil uVision project STM32F407VGT6.uvprojx, settings and files
target STM32G407VGT6 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VGT6
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, USE_FULL_ASSERT, USE_USB_OTG_FS,DEBUG
  c include: ..\inc;..\Libraries\CMSIS\Include;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Utilities\STM32_EVAL;..\Libraries\Device\STM32F4xx\Include;..\src;..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\STM32F4lib;..\MDK;..\applications;..\build;..\inc;..\Libraries;..\Utilities;..\include;..\drivers;..\finsh;..\APP;..\drivers\ff10a\src;..\LD_Driver;..\RT-THREAD\finsh;..\lua
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: system_stm32f4xx.c uart_debug.c usb_bsp.c usbh_usr.c
    ./: debug.c commu.c
    ../STM32F4lib/: stm32f4lib.c
  group periph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_gpio.c misc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_spi.c
  group usb_host
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group usb_class
    ../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group Startup
    ../src/: startup_stm32f4xx.s
  group Applications
    ../applications/: application.c startup.c
  group Drivers
    ../drivers/: board.c LED.C serial.c stm32f4xx_it.c usart.c oled.c W25Q16.C LD3320_main.c
    ../Libraries/: spi.c
    ../drivers/ff10a/src/: diskio.c ff.c
  group Kernel
    ../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../cotex/: backtrace.c context_rvds.S cpuport.c div0.c showmem.c
  group App
    ../APP/: app_interface.c mouse_gesture.c windows_api.c inifile.c ahk_analyser.c key_remap.c draw_bmp.c pwd.c lua_app.c
  group lua
    ../lua/armlibc/: stubs.c mem_std.c
    ../lua/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c ldump.c legc.c lexamplelib.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lrotable.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c lua_in_finsh.c lundump.c lvm.c lzio.c

# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\USB\CONFIG;..\USB\LIB;D:\Keil\ARM\INC\ST\STM32F10x;..\HARDWARE\USB;..\USER;..\STM32lib;..\..\..\STM32_USB_CH341\DiscreteFile\SYSTEM\sys;..\HARDWARE\FLASH;..\HARDWARE\lib;..\FATFS;..\app;..\LUA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: STM32F10x.s
  group APP
    ../app/: app.c lua_inf.c
  group USER
    ./: keyboard.c led.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../STM32lib/: stm32lib.c
    ./: commu.c commu_mcu.c
    ../HARDWARE/USB/: usb_process.c
    ../HARDWARE/FLASH/: W25Q16.C
    ../HARDWARE/SPI/: spi.c
  group USB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_hw.c
  group USBCFG
    ../USB/CONFIG/: hw_config.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c mass_mal.c usb_bot.c usb_scsi.c memory.c scsi_data.c
  group FATFS
    ../FATFS/: diskio.c ff.c
  group LUA
    ../LUA/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lutf8lib.c lvm.c lzio.c
